# IAR project CEC322_Lab8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: CEC322_Lab8.bin
  ILINK.IlinkOutputFile: uart_echo.out
  ILINK.IlinkIcfFile: CEC322_Lab8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
    ../../../../sensorlib/ewarm/Exe/: sensorlib.a
  group Source
    ../lbHeaders/Game/: asteroids.c bullet.c spaceship.c sprite.c
    ../lbHeaders/Graphics/: asteroids_graphics.c luke_graphics.c pm_images.c
    ../mrbUtil/: cec322Peripherals.c cec322Util.c i2cwrite.c queue.c
    ../drivers/: cfal96x64x16.c
    ./: Lab_8_Main.c startup_ewarm.c
    ../lbHeaders/: lb_buttons.c
